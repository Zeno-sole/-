# Keil uVision project DustControl.uvprojx, settings and files
target DustControl (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DustControl +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\main;..\User\stm32fxxx;..\User\bsp;..\Libraries\Third_Party\Software\uC-Config;..\Libraries\Third_Party\Software\uC-Config\OS\uCOS-III;..\Libraries\Third_Party\Software\uC-CPU;..\Libraries\Third_Party\Software\uC-CPU\ARM-Cortex-M4\RealView;..\Libraries\Third_Party\Software\uC-LIB;..\Libraries\Third_Party\Software\uCOS-III\Source;..\Libraries\Third_Party\Software\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\User\gprs;..\Libraries\Third_Party\freemodbus-v1.5.0\modbus\ascii;..\Libraries\Third_Party\freemodbus-v1.5.0\modbus\include;..\Libraries\Third_Party\freemodbus-v1.5.0\modbus\rtu;..\Libraries\Third_Party\freemodbus-v1.5.0\port;..\User\STMFLASH;..\User\DWIN;..\User\PWM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ../User/main/: main.c app_cfg.h opt.c opt.h
  group bsp
    ../User/bsp/: bsp.c bsp.h bsp_debug_usart.c bsp_debug_usart.h bsp_config_usart.c bsp_config_usart.h bsp_gpio.c bsp_gpio.h bsp_int.c bsp_int.h bsp_debug.h
    ../User/STMFLASH/: stmflash.c
    ../User/PWM/: pwm.c
  group DWIN
    ../User/DWIN/: DWIN.c
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_tim.c
  group MDK-ARM
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c stm32f10x.h system_stm32f10x.h
  group stm32fxxx
    ../User/stm32fxxx/: stm32f10x_it.c stm32f10x_conf.h stm32f10x_it.h
  group port
    ../Libraries/Third_Party/freemodbus-v1.5.0/port/: portevent.c portserial.c porttimer.c
  group freemodbus-v1.5.0
    ../Libraries/Third_Party/freemodbus-v1.5.0/modbus/: mb.c
    ../Libraries/Third_Party/freemodbus-v1.5.0/modbus/rtu/: mbcrc.c mbrtu.c
    ../Libraries/Third_Party/freemodbus-v1.5.0/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../Libraries/Third_Party/freemodbus-v1.5.0/modbus/ascii/: mbascii.c
  group uC-Config
    ../Libraries/Third_Party/Software/uC-Config/: cpu_bsp.c os_app_hooks.c cpu_cfg.h lib_cfg.h os_app_hooks.h os_cfg.h os_cfg_app.h
    ../Libraries/Third_Party/Software/uC-Config/OS/uCOS-III/: bsp_os.c bsp_os.h
  group uC-CPU
    ../Libraries/Third_Party/Software/uC-CPU/: cpu_core.c
    ../Libraries/Third_Party/Software/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group uC-LIB
    ../Libraries/Third_Party/Software/uC-LIB/: lib_ascii.c lib_mem.c lib_str.c
    ../Libraries/Third_Party/Software/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uCOS-III-Source
    ../Libraries/Third_Party/Software/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uCOS-III-Ports
    ../Libraries/Third_Party/Software/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu_a.asm os_cpu.h
